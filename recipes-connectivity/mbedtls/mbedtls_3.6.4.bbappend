PR .= ".1"
SRC_URI = "gitsm://github.com/Mbed-TLS/mbedtls.git;protocol=https;branch=mbedtls-3.6;rev=c765c831e5c2a0971410692f92f7a81d6ec65ec2\
            file://run-ptest \
            "

SRCREV = ""
