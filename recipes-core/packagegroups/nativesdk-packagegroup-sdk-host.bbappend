PR .= ".1"

RDEPENDS_${PN} += " \
    nativesdk-cramfs-tools \
"
