SUMMARY = "Alif Linux Hello World Image"
DESCRIPTION = "Linux Hello World in continous Loop"
LICENSE = "MIT"

inherit core-image

IMAGE_INSTALL = "helloworld"
