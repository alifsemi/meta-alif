PR. = ".1"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI = "git://10.10.10.22/linux.git;protocol=http;branch=bolt-5.4.y \
           file://defconfig"

SRCREV= "c1ed8fac4a325a19e20d407269432d67fa78af2c"
